options:
  parameters:
    author: hrg
    generate_options: qt_gui
    id: fm_receiver
    output_language: python
    title: FM Receiver
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    label: freq
    orient: Qt.Horizontal
    start: 70e6
    step: 1e3
    stop: 5e9
    value: 1e9
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '75'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    bw0: 32e6
    center_freq0: freq
    dc_offs_enb0: '""'
    dev_addr: '"addr=192.168.10.12"'
    dev_args: '""'
    gain0: gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
